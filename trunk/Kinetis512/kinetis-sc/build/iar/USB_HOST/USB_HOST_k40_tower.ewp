# IAR project USB_HOST_k40_tower.ewp, settings and files
configuration RAM_128KB (ARM, debug)
  General.OGChipSelectEditMenu: K40Xxxx Freescale K40Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER; TWR_K40X256
  ICCARM.CCIncludePath2: ..\..\..\src\projects\USB_HOST\source\bsp; ..\..\..\src\projects\USB_HOST\source\bsp\p2; ..\..\..\src\projects\USB_HOST\Source\classes\cdc; ..\..\..\src\projects\USB_HOST\Source\classes\common; ..\..\..\src\projects\USB_HOST\Source\classes\hid; ..\..\..\src\projects\USB_HOST\Source\classes\hub; ..\..\..\src\projects\USB_HOST\Source\classes\msd; ..\..\..\src\projects\USB_HOST\Source\classes\msd\mfs; ..\..\..\src\projects\USB_HOST\Source\classes\phdc; ..\..\..\src\projects\USB_HOST\Source\driver; ..\..\..\src\projects\USB_HOST\Source\host_common; ..\..\..\src\projects\USB_HOST\examples\common; ..\..\..\src\projects\USB_HOST\examples\hid\mouse; ..\..\..\src\projects\USB_HOST; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USB_HOST_k40_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_64KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TWR_K40X256
  ICCARM.CCIncludePath2: ..\..\..\src\projects\USB_HOST; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\
  ILINK.IlinkIcfFile: ..\config files\64KB_Ram.icf
configuration RAM_32KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TWR_K40X256
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\32KB_Ram.icf
configuration FLASH_512KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TWR_K40X256
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\512KB_Pflash.icf
configuration FLASH_256KB_PFLASH_256KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TWR_K40X256
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash_256KB_Dflash.icf
configuration FLASH_256KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TWR_K40X256
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash.icf
configuration FLASH_128KB_PFLASH_128KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TWR_K40X256
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash_128KB_Dflash.icf
configuration FLASH_128KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TWR_K40X256
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
configuration FLASH_64KB_PFLASH_64KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TWR_K40X256
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash_64KB_Dflash.icf
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s dma_channels.h start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MK40N512VMD100.h MK40X256VMD100.h MK60N512VMD100.h MK60X256VMD100.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 128KB_Pflash.icf 128KB_Pflash_128KB_Dflash.icf 128KB_Ram.icf 256KB_Pflash.icf 256KB_Pflash_256KB_Dflash.icf 32KB_Ram.icf 512KB_Pflash.icf 64KB_Pflash_64KB_Dflash.icf 64KB_Ram.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: k40_tower.h k60_tower.h
  group project
    ../../../src/projects/USB_HOST/: common.h isr.h startup.c startup.h write.c
    ../../../src/projects/USB_HOST/examples/hid/mouse/: hidmouse.c hidmouse.h usb_classes.h
    ../../../src/projects/USB_HOST/examples/common/: rtc.c rtc.h
  group project/bsp
    ../../../src/projects/USB_HOST/Source/bsp/mcf51JM/: P2.c
  group project/classes
    ../../../src/projects/USB_HOST/Source/classes/common/: usb_classes.c
    ../../../src/projects/USB_HOST/Source/classes/hid/: usb_host_hid.c usb_host_hid.h
    ../../../src/projects/USB_HOST/Source/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group project/driver
    ../../../src/projects/USB_HOST/Source/driver/: khci.c khci.h psptypes.h types.h usb.h usb_bsp.h usb_desc.h usbevent.c usbevent.h usbmsgq.c usbmsgq.h usbprv.h usbprv_host.h usbsem.c usbsem.h
  group project/host_common
    ../../../src/projects/USB_HOST/Source/host_common/: host_ch9.c host_ch9.h host_close.c host_close.h host_cnfg.h host_cnl.c host_cnl.h host_common.c host_common.h host_debug.h host_dev_list.c host_dev_list.h host_driver.c host_driver.h host_main.c host_main.h host_rcv.c host_rcv.h host_shut.c host_shut.h host_snd.c host_snd.h hostapi.h
