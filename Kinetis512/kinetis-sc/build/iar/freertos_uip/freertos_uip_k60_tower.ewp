# IAR project freertos_uip_k60_tower.ewp, settings and files
configuration RAM_128KB (ARM, debug)
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER; TWR_K60N512; IAR_KINETIS
  ICCARM.CCIncludePath2: ..\..\..\src\projects\freertos_uip; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\enet; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\; ..\..\..\src\projects\freertos_uip\FreeRTOS\Source\include; ..\..\..\src\projects\freertos_uip\FreeRTOS\Source\portable\IAR\ARM_CM4; ..\..\..\src\projects\freertos_uip\FreeRTOS\Demo\CORTEX_KINETIS_IAR; ..\..\..\src\projects\freertos_uip\FreeRTOS\Source; ..\..\..\src\projects\freertos_uip\uip-1.0\uip; ..\..\..\src\projects\freertos_uip\ENET_uip_driver; ..\..\..\src\projects\freertos_uip\FreeRTOS\Demo\CORTEX_KINETIS_IAR\webserver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\src\projects\freertos_uip\FreeRTOS\Demo\CORTEX_KINETIS_IAR
  OBJCOPY.OOCOutputFile: freertos_uip_k60_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_64KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; FIREBIRD; MARCONI_144
  ICCARM.CCIncludePath2: ..\..\..\src\projects\freertos_uip; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\
  ILINK.IlinkIcfFile: ..\config files\64KB_Ram.icf
configuration RAM_32KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; FIREBIRD; MARCONI_144
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: ..\config files\32KB_Ram.icf
configuration FLASH_512KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\512KB_Pflash.icf
configuration FLASH_256KB_PFLASH_256KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TOWER; TWR_K40X256
  ICCARM.CCIncludePath2: as above
  postbuild: srec2jlink "$EXE_DIR$\$PROJ_FNAME$.srec"
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash_256KB_Dflash.icf
configuration FLASH_256KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TOWER; TWR_K40X256
  ICCARM.CCIncludePath2: as above
  postbuild: srec2jlink "$EXE_DIR$\$PROJ_FNAME$.srec"
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash.icf
configuration FLASH_128KB_PFLASH_128KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TOWER; TWR_K40X256
  ICCARM.CCIncludePath2: as above
  postbuild: srec2jlink "$EXE_DIR$\$PROJ_FNAME$.srec"
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash_128KB_Dflash.icf
configuration FLASH_128KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TOWER; TWR_K40X256
  ICCARM.CCIncludePath2: as above
  postbuild: srec2jlink "$EXE_DIR$\$PROJ_FNAME$.srec"
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
configuration FLASH_64KB_PFLASH_64KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR; TOWER; TWR_K40X256
  ICCARM.CCIncludePath2: as above
  postbuild: srec2jlink "$EXE_DIR$\$PROJ_FNAME$.srec"
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash_64KB_Dflash.icf
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MK40N512VMD100.h MK60N512VMD100.h
  group drivers/enet
    ../../../src/drivers/enet/: enet.c enet.h eth.h eth_phy.c eth_phy.h mii.c mii.h nbuf.c nbuf.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 128KB_Pflash.icf 128KB_Pflash_128KB_Dflash.icf 128KB_Ram.icf 256KB_Pflash.icf 256KB_Pflash_256KB_Dflash.icf 32KB_Ram.icf 512KB_Pflash.icf 64KB_Pflash_64KB_Dflash.icf 64KB_Ram.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: k60_tower.h
  group project
    ../../../src/projects/freertos_uip/: isr.h main.c
  group project/enet_uip_driver
    ../../../src/projects/freertos_uip/ENET_uip_driver/: enet_freertos.c enet_freertos.h
  group project/FreeRTOS/App
    ../../../src/projects/freertos_uip/FreeRTOS/Demo/CORTEX_KINETIS_IAR/: FreeRTOSConfig.h ParTest.c partest.h
  group project/FreeRTOS/App/WebServer
    ../../../src/projects/freertos_uip/FreeRTOS/Demo/CORTEX_KINETIS_IAR/webserver/: clock-arch.h http-strings.c http-strings.h httpd-cgi.c httpd-cgi.h httpd-fs.c httpd-fs.h httpd-fsdata.h httpd.c httpd.h pack_struct_end.h pack_struct_start.h uip-conf.h uIP_Task.c webserver.h
  group project/FreeRTOS/Source
    ../../../src/projects/freertos_uip/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c
  group project/FreeRTOS/Source/Include
    ../../../src/projects/freertos_uip/FreeRTOS/Source/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h
  group project/FreeRTOS/Source/Portable/IAR
    ../../../src/projects/freertos_uip/FreeRTOS/Source/portable/IAR/ARM_CM4/: port.c portasm.s portmacro.h
  group project/FreeRTOS/Source/Portable/MemMang
    ../../../src/projects/freertos_uip/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group project/init
    ../../../src/projects/freertos_uip/: common.h startup.c startup.h write.c
  group project/uip
    ../../../src/projects/freertos_uip/uip-1.0/uip/: clock.h lc-addrlabels.h lc-switch.h lc.h psock.c psock.h pt.h timer.c timer.h uip-fw.c uip-fw.h uip-neighbor.c uip-neighbor.h uip-split.c uip-split.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uiplib.c uiplib.h uipopt.h
