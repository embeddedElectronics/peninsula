# IAR project tsi_low_pwr_k60_tower.ewp, settings and files
configuration RAM_128KB (ARM, debug)
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\..\src\projects\tsi_low_pwr; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tsi_low_pwr_k60_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_64KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\src\projects\tsi_low_pwr; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\
  OBJCOPY.OOCOutputFile: hello_world_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\64KB_Ram.icf
configuration RAM_32KB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: hello_world_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\32KB_Ram.icf
configuration FLASH_512KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\512KB_Pflash.icf
configuration FLASH_256KB_PFLASH_256KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: hello_world_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash_256KB_Dflash.icf
configuration FLASH_256KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: hello_world_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\256KB_Pflash.icf
configuration FLASH_128KB_PFLASH_128KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: hello_world_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash_128KB_Dflash.icf
configuration FLASH_128KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: hello_world_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
configuration FLASH_64KB_PFLASH_64KB_DFLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: hello_world_k60_tower.srec
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash_64KB_Dflash.icf
  group common
    ../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s dma_channels.h start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MK40N512VMD100.h MK40X256VMD100.h MK60N512VMD100.h MK60X256VMD100.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 128KB_Pflash.icf 128KB_Pflash_128KB_Dflash.icf 128KB_Ram.icf 256KB_Pflash.icf 256KB_Pflash_256KB_Dflash.icf 32KB_Ram.icf 512KB_Pflash.icf 64KB_Pflash_64KB_Dflash.icf 64KB_Ram.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: k40_tower.h k60_tower.h
  group project
    ../../../src/projects/tsi_low_pwr/: isr.h misc.c misc.h tsi.c tsi.h tsi_low_pwr.c
