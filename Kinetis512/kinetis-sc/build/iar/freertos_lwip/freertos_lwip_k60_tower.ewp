# IAR project freertos_lwip_k60_tower.ewp, settings and files
configuration RAM_128KB (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER; TWR_K60N512; IAR_KINETIS; LWIP_PERF_SETTINGS=0; ENET_HARDWARE_CHECKSUM=0; ENET_HARDWARE_SHIFT=1
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: ..\..\..\src\projects\freertos_lwip; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\enet; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\platforms; ..\; ..\..\..\src\projects\freertos_lwip\FreeRTOS\Source\include; ..\..\..\src\projects\freertos_lwip\FreeRTOS\Source\portable\IAR\ARM_CM4; ..\..\..\src\projects\freertos_lwip\FreeRTOS\Demo\CORTEX_KINETIS_IAR; ..\..\..\src\projects\freertos_lwip\FreeRTOS\Demo\CORTEX_KINETIS_IAR\include; ..\..\..\src\projects\freertos_lwip\FreeRTOS\Source; ..\..\..\src\projects\freertos_lwip\lwip-1.3.2\src\include\; ..\..\..\src\projects\freertos_lwip\lwip-1.3.2\src\include\ipv4\; ..\..\..\src\projects\freertos_lwip\lwip-1.3.2\src\include\ipv4\lwip; ..\..\..\src\projects\freertos_lwip\lwip-1.3.2\src\include\lwip; ..\..\..\src\projects\freertos_lwip\lwip-1.3.2\src\include\netif; ..\..\..\src\projects\freertos_lwip\FreeRTOS+lwIP; ..\..\..\src\projects\freertos_lwip\FreeRTOS+lwIP\lwip
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\src\projects\freertos_lwip\FreeRTOS\Demo\CORTEX_KINETIS_IAR
  OBJCOPY.OOCOutputFile: freertos_lwip_k60_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_512KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\512KB_Pflash.icf
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group cpu/headers
    ../../../src/cpu/headers/: MK40N512VMD100.h MK60N512VMD100.h
  group drivers/enet
    ../../../src/drivers/enet/: enet.c enet.h eth.h eth_phy.c eth_phy.h mii.c mii.h nbuf.c nbuf.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 128KB_Pflash.icf 128KB_Pflash_128KB_Dflash.icf 128KB_Ram.icf 256KB_Pflash.icf 256KB_Pflash_256KB_Dflash.icf 32KB_Ram.icf 512KB_Pflash.icf 64KB_Pflash_64KB_Dflash.icf 64KB_Ram.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: k60_tower.h
  group project
    ../../../src/projects/freertos_lwip/: isr.h main.c
  group project/FreeRTOS/App
    ../../../src/projects/freertos_lwip/FreeRTOS/Demo/CORTEX_KINETIS_IAR/: FreeRTOSConfig.h ParTest.c partest.h
  group project/FreeRTOS/App/include
    ../../../src/projects/freertos_lwip/FreeRTOS/Demo/CORTEX_KINETIS_IAR/include/: HTTPDemo.h throughput_test.h
  group project/FreeRTOS/App/Throughput
    ../../../src/projects/freertos_lwip/FreeRTOS/Demo/CORTEX_KINETIS_IAR/Throughput/: throughput_test.c
  group project/FreeRTOS/App/webserver
    ../../../src/projects/freertos_lwip/FreeRTOS/Demo/CORTEX_KINETIS_IAR/lwipWebServer/: HTTPDemo.c
  group project/FreeRTOS/Source
    ../../../src/projects/freertos_lwip/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c
  group project/FreeRTOS/Source/Include
    ../../../src/projects/freertos_lwip/FreeRTOS/Source/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h
  group project/FreeRTOS/Source/Portable/IAR
    ../../../src/projects/freertos_lwip/FreeRTOS/Source/portable/IAR/ARM_CM4/: port.c portasm.s portmacro.h
  group project/FreeRTOS/Source/Portable/MemMang
    ../../../src/projects/freertos_lwip/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group project/FreeRTOS+lwIP+ENET
    ../../../src/projects/freertos_lwip/FreeRTOS+lwIP/: etharp.c ethernetif.c sys_arch.c
  group project/FreeRTOS+lwIP+ENET/arch
    ../../../src/projects/freertos_lwip/FreeRTOS+lwIP/arch/: cc.h cpu.h lwip_errno.h perf.h sys_arch.h
  group project/FreeRTOS+lwIP+ENET/lwIP
    ../../../src/projects/freertos_lwip/FreeRTOS+lwIP/lwip/: lwipopts.h
  group project/init
    ../../../src/projects/freertos_lwip/: common.h startup.c startup.h write.c
  group project/lwIP/api
    ../../../src/projects/freertos_lwip/lwip-1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group project/lwIP/core
    ../../../src/projects/freertos_lwip/lwip-1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group project/lwIP/core/ipv4
    ../../../src/projects/freertos_lwip/lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group project/lwIP/core/snmp
    ../../../src/projects/freertos_lwip/lwip-1.3.2/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group project/lwIP/include/ipv4
    ../../../src/projects/freertos_lwip/lwip-1.3.2/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet.h inet_chksum.h ip.h ip_addr.h ip_frag.h
  group project/lwIP/include/lwip
    ../../../src/projects/freertos_lwip/lwip-1.3.2/src/include/lwip/: api.h api_msg.h arch.h debug.h def.h dhcp.h dns.h err.h init.h mem.h memp.h memp_std.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h snmp_asn1.h snmp_msg.h snmp_structs.h sockets.h stats.h sys.h tcp.h tcpip.h udp.h
  group project/lwIP/include/netif
    ../../../src/projects/freertos_lwip/lwip-1.3.2/src/include/netif/: etharp.h loopif.h ppp_oe.h slipif.h
