<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USB_dual_role_k60_tower.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\USB_dual_role_k40_tower.ewp</path>
  </project>
  <batchBuild/>
</workspace>


